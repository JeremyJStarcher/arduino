# Repository JeremyJStarcher/arduino (continued)

## KiCad design atari-keyboard/atari-keyboard/atari-keyboard-kicad-5/atari-keyboard.kicad_pcb

Schematic: atari-keyboard.sch

Parts:
D1: MENU; D_A-405_P7.62mm_Horizontal
D2: TURBO; D_A-405_P7.62mm_Horizontal
D3: RESET; D_A-405_P7.62mm_Horizontal
D4: OPTION; D_A-405_P7.62mm_Horizontal
D5: SELECT; D_A-405_P7.62mm_Horizontal
D6: START; D_A-405_P7.62mm_Horizontal
D7: HELP; D_A-405_P7.62mm_Horizontal
D8: ESC; D_A-405_P7.62mm_Horizontal
D9, D57: LSHIFT; D_A-405_P7.62mm_Horizontal
D10: 1; D_A-405_P7.62mm_Horizontal
D11: 2; D_A-405_P7.62mm_Horizontal
D12: 3; D_A-405_P7.62mm_Horizontal
D13: 4; D_A-405_P7.62mm_Horizontal
D14: 5; D_A-405_P7.62mm_Horizontal
D15: 6; D_A-405_P7.62mm_Horizontal
D16: 7; D_A-405_P7.62mm_Horizontal
D17: 8; D_A-405_P7.62mm_Horizontal
D18: UP; D_A-405_P7.62mm_Horizontal
D19: 9; D_A-405_P7.62mm_Horizontal
D20: 0; D_A-405_P7.62mm_Horizontal
D21: <; D_A-405_P7.62mm_Horizontal
D22: >; D_A-405_P7.62mm_Horizontal
D23: BS; D_A-405_P7.62mm_Horizontal
D24: BRK; D_A-405_P7.62mm_Horizontal
D25: TAB; D_A-405_P7.62mm_Horizontal
D26: Q; D_A-405_P7.62mm_Horizontal
D27: DOWN; D_A-405_P7.62mm_Horizontal
D28: W; D_A-405_P7.62mm_Horizontal
D29: E; D_A-405_P7.62mm_Horizontal
D30: R; D_A-405_P7.62mm_Horizontal
D31: T; D_A-405_P7.62mm_Horizontal
D32: Y; D_A-405_P7.62mm_Horizontal
D33: U; D_A-405_P7.62mm_Horizontal
D34: I; D_A-405_P7.62mm_Horizontal
D35: O; D_A-405_P7.62mm_Horizontal
D36: LEFT; D_A-405_P7.62mm_Horizontal
D37: P; D_A-405_P7.62mm_Horizontal
D38: [-]; D_A-405_P7.62mm_Horizontal
D39: [=]; D_A-405_P7.62mm_Horizontal
D40: RET; D_A-405_P7.62mm_Horizontal
D41: CTRL; D_A-405_P7.62mm_Horizontal
D42: A; D_A-405_P7.62mm_Horizontal
D43: S; D_A-405_P7.62mm_Horizontal
D44: D; D_A-405_P7.62mm_Horizontal
D45: RIGHT; D_A-405_P7.62mm_Horizontal
D46: F; D_A-405_P7.62mm_Horizontal
D47: G; D_A-405_P7.62mm_Horizontal
D48: H; D_A-405_P7.62mm_Horizontal
D49: J; D_A-405_P7.62mm_Horizontal
D50: K; D_A-405_P7.62mm_Horizontal
D51: L; D_A-405_P7.62mm_Horizontal
D52: [;]; D_A-405_P7.62mm_Horizontal
D53: [+]; D_A-405_P7.62mm_Horizontal
D54: N; D_A-405_P7.62mm_Horizontal
D55: MULT; D_A-405_P7.62mm_Horizontal
D56: CAPS; D_A-405_P7.62mm_Horizontal
D58: Z; D_A-405_P7.62mm_Horizontal
D59: X; D_A-405_P7.62mm_Horizontal
D60: C; D_A-405_P7.62mm_Horizontal
D61: V; D_A-405_P7.62mm_Horizontal
D62: B; D_A-405_P7.62mm_Horizontal
D63: M; D_A-405_P7.62mm_Horizontal
D64: JS2_UP; D_A-405_P7.62mm_Horizontal
D65: JS2_TRIGGER; D_A-405_P7.62mm_Horizontal
D66: JS2_DOWN; D_A-405_P7.62mm_Horizontal
D67: JS2_LEFT; D_A-405_P7.62mm_Horizontal
D68: JS2_RIGHT; D_A-405_P7.62mm_Horizontal
D69: FN; D_A-405_P7.62mm_Horizontal
D70: INV; D_A-405_P7.62mm_Horizontal
D71: SPC; D_A-405_P7.62mm_Horizontal
D72: [,]; D_A-405_P7.62mm_Horizontal
D73: JS1_UP; D_A-405_P7.62mm_Horizontal
D74: JS1_TRIGGER; D_A-405_P7.62mm_Horizontal
D75: JS1_DOWN; D_A-405_P7.62mm_Horizontal
D76: JS1_LEFT; D_A-405_P7.62mm_Horizontal
D77: JS1_RIGHT; D_A-405_P7.62mm_Horizontal
D78: [.]; D_A-405_P7.62mm_Horizontal
D79: [/]; D_A-405_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Removed LEDS. Wire soldered to the board; PinSocket_1x02_P2.54mm_Vertical
J2: PLAYER 1; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Hou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
J3: PLAYER 2; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Hou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
SW1: MENU; SW_Cherry_MX_1.00u_PCB
SW2: TURBO; SW_Cherry_MX_1.00u_PCB
SW3: RESET; SW_Cherry_MX_1.00u_PCB
SW4: OPTION; SW_Cherry_MX_1.00u_PCB
SW5: SELECT; SW_Cherry_MX_1.00u_PCB
SW6: START; SW_Cherry_MX_1.00u_PCB
SW7: HELP; SW_Cherry_MX_1.00u_PCB
SW8: ESC; SW_Cherry_MX_1.25u_PCB
SW9: RSHIFT; SW_Cherry_MX_1.75u_PCB
SW10: 1; SW_Cherry_MX_1.00u_PCB
SW11: 2; SW_Cherry_MX_1.00u_PCB
SW12: 3; SW_Cherry_MX_1.00u_PCB
SW13: 4; SW_Cherry_MX_1.00u_PCB
SW14: 5; SW_Cherry_MX_1.00u_PCB
SW15: 6; SW_Cherry_MX_1.00u_PCB
SW16: 7; SW_Cherry_MX_1.00u_PCB
SW17: 8; SW_Cherry_MX_1.00u_PCB
SW18: UP; SW_Cherry_MX_1.00u_PCB
SW19: 9; SW_Cherry_MX_1.00u_PCB
SW20: 0; SW_Cherry_MX_1.00u_PCB
SW21: <; SW_Cherry_MX_1.00u_PCB
SW22: >; SW_Cherry_MX_1.00u_PCB
SW23: BS; SW_Cherry_MX_2.00u_PCB
SW24: BRK; SW_Cherry_MX_1.00u_PCB
SW25: TAB; SW_Cherry_MX_1.75u_PCB
SW26: Q; SW_Cherry_MX_1.00u_PCB
SW27: DOWN; SW_Cherry_MX_1.00u_PCB
SW28: W; SW_Cherry_MX_1.00u_PCB
SW29: E; SW_Cherry_MX_1.00u_PCB
SW30: R; SW_Cherry_MX_1.00u_PCB
SW31: T; SW_Cherry_MX_1.00u_PCB
SW32: Y; SW_Cherry_MX_1.00u_PCB
SW33: U; SW_Cherry_MX_1.00u_PCB
SW34: I; SW_Cherry_MX_1.00u_PCB
SW35: O; SW_Cherry_MX_1.00u_PCB
SW36: LEFT; SW_Cherry_MX_1.00u_PCB
SW37: P; SW_Cherry_MX_1.00u_PCB
SW38: [-]; SW_Cherry_MX_1.00u_PCB
SW39: [=]; SW_Cherry_MX_1.00u_PCB
SW40: RET; SW_Cherry_MX_1.50u_PCB
SW41: CTRL; SW_Cherry_MX_2.00u_PCB
SW42: A; SW_Cherry_MX_1.00u_PCB
SW43: S; SW_Cherry_MX_1.00u_PCB
SW44: D; SW_Cherry_MX_1.00u_PCB
SW45: RIGHT; SW_Cherry_MX_1.00u_PCB
SW46: F; SW_Cherry_MX_1.00u_PCB
SW47: G; SW_Cherry_MX_1.00u_PCB
SW48: H; SW_Cherry_MX_1.00u_PCB
SW49: J; SW_Cherry_MX_1.00u_PCB
SW50: K; SW_Cherry_MX_1.00u_PCB
SW51: L; SW_Cherry_MX_1.00u_PCB
SW52: [;]; SW_Cherry_MX_1.00u_PCB
SW53: [+]; SW_Cherry_MX_1.00u_PCB
SW54: N; SW_Cherry_MX_1.00u_PCB
SW55: MULT; SW_Cherry_MX_1.00u_PCB
SW56: CAPS; SW_Cherry_MX_1.25u_PCB
SW57: LSHIFT; SW_Cherry_MX_2.25u_PCB
SW58: Z; SW_Cherry_MX_1.00u_PCB
SW59: X; SW_Cherry_MX_1.00u_PCB
SW60: C; SW_Cherry_MX_1.00u_PCB
SW61: V; SW_Cherry_MX_1.00u_PCB
SW62: B; SW_Cherry_MX_1.00u_PCB
SW63: M; SW_Cherry_MX_1.00u_PCB
SW64: FN; SW_Cherry_MX_1.75u_PCB
SW65: INV; SW_Cherry_MX_1.00u_PCB
SW66: SPC; SW_Cherry_MX_6.25u_PCB
SW67: [,]; SW_Cherry_MX_1.00u_PCB
SW68: [.]; SW_Cherry_MX_1.00u_PCB
SW69: [/]; SW_Cherry_MX_1.00u_PCB
U1: ProMicro

Connections:
/JS1_+5: J2.7
/JS1_APaddle: J2.9
/JS1_BPaddle: J2.5
/JS1_DOWN: D75.2 (A), J2.2
/JS1_LEFT: D76.2 (A), J2.3
/JS1_RIGHT: D77.2 (A), J2.4
/JS1_TRIGGER: D74.2 (A), J2.6
/JS1_UP: D73.2 (A), J2.1
/JS2_APaddle: J3.9
/JS2_BPaddle: J3.5
/JS2_DOWN: D66.2 (A), J3.2
/JS2_LEFT: D67.2 (A), J3.3
/JS2_RIGHT: D68.2 (A), J3.4
/JS2_TRIGGER: D65.2 (A), J3.6
/JS2_UP: D64.2 (A), J3.1
/JS_2+5: J3.7
C1: SW1.2 (B), SW10.2 (B), SW19.2 (B), SW28.2 (B), SW37.2 (B), SW46.2 (B), SW55.2 (B), U1.20 (F4)
C2: SW2.2 (B), SW11.2 (B), SW20.2 (B), SW29.2 (B), SW38.2 (B), SW47.2 (B), SW56.2 (B), U1.19 (F5)
C3: SW3.2 (B), SW12.2 (B), SW21.2 (B), SW30.2 (B), SW39.2 (B), SW48.2 (B), SW57.2 (B), U1.18 (F6)
C4: SW4.2 (B), SW13.2 (B), SW22.2 (B), SW31.2 (B), SW40.2 (B), SW49.2 (B), SW58.2 (B), U1.17 (F7)
C5: SW5.2 (B), SW14.2 (B), SW23.2 (B), SW32.2 (B), SW41.2 (B), SW50.2 (B), SW59.2 (B), U1.16 (SCLK)
C6: SW6.2 (B), SW15.2 (B), SW24.2 (B), SW33.2 (B), SW42.2 (B), SW51.2 (B), SW60.2 (B), SW64.2 (B), SW68.2 (B), U1.15 (MISO)
C7: SW7.2 (B), SW16.2 (B), SW25.2 (B), SW34.2 (B), SW43.2 (B), SW52.2 (B), SW61.2 (B), SW65.2 (B), SW69.2 (B), U1.14 (MOSI)
C8: SW8.2 (B), SW17.2 (B), SW26.2 (B), SW35.2 (B), SW44.2 (B), SW53.2 (B), SW62.2 (B), SW66.2 (B), U1.13 (B6)
C9: J1.1, SW9.2 (B), SW18.2 (B), SW27.2 (B), SW36.2 (B), SW45.2 (B), SW54.2 (B), SW63.2 (B), SW67.2 (B)
unnamed: D1.2 (A), SW1.1 (A)
unnamed: D2.2 (A), SW2.1 (A)
unnamed: D3.2 (A), SW3.1 (A)
unnamed: D4.2 (A), SW4.1 (A)
unnamed: D5.2 (A), SW5.1 (A)
unnamed: D6.2 (A), SW6.1 (A)
unnamed: D7.2 (A), SW7.1 (A)
unnamed: D8.2 (A), SW8.1 (A)
unnamed: D9.2 (A), SW9.1 (A)
unnamed: D10.2 (A), SW10.1 (A)
unnamed: D11.2 (A), SW11.1 (A)
unnamed: D12.2 (A), SW12.1 (A)
unnamed: D13.2 (A), SW13.1 (A)
unnamed: D14.2 (A), SW14.1 (A)
unnamed: D15.2 (A), SW15.1 (A)
unnamed: D16.2 (A), SW16.1 (A)
unnamed: D17.2 (A), SW17.1 (A)
unnamed: D18.2 (A), SW18.1 (A)
unnamed: D19.2 (A), SW19.1 (A)
unnamed: D20.2 (A), SW20.1 (A)
unnamed: D21.2 (A), SW21.1 (A)
unnamed: D22.2 (A), SW22.1 (A)
unnamed: D23.2 (A), SW23.1 (A)
unnamed: D24.2 (A), SW24.1 (A)
unnamed: D25.2 (A), SW25.1 (A)
unnamed: D26.2 (A), SW26.1 (A)
unnamed: D27.2 (A), SW27.1 (A)
unnamed: D28.2 (A), SW28.1 (A)
unnamed: D29.2 (A), SW29.1 (A)
unnamed: D30.2 (A), SW30.1 (A)
unnamed: D31.2 (A), SW31.1 (A)
unnamed: D32.2 (A), SW32.1 (A)
unnamed: D33.2 (A), SW33.1 (A)
unnamed: D34.2 (A), SW34.1 (A)
unnamed: D35.2 (A), SW35.1 (A)
unnamed: D36.2 (A), SW36.1 (A)
unnamed: D37.2 (A), SW37.1 (A)
unnamed: D38.2 (A), SW38.1 (A)
unnamed: D39.2 (A), SW39.1 (A)
unnamed: D40.2 (A), SW40.1 (A)
unnamed: D41.2 (A), SW41.1 (A)
unnamed: D42.2 (A), SW42.1 (A)
unnamed: D43.2 (A), SW43.1 (A)
unnamed: D44.2 (A), SW44.1 (A)
unnamed: D45.2 (A), SW45.1 (A)
unnamed: D46.2 (A), SW46.1 (A)
unnamed: D47.2 (A), SW47.1 (A)
unnamed: D48.2 (A), SW48.1 (A)
unnamed: D49.2 (A), SW49.1 (A)
unnamed: D50.2 (A), SW50.1 (A)
unnamed: D51.2 (A), SW51.1 (A)
unnamed: D52.2 (A), SW52.1 (A)
unnamed: D53.2 (A), SW53.1 (A)
unnamed: D54.2 (A), SW54.1 (A)
unnamed: D55.2 (A), SW55.1 (A)
unnamed: D56.2 (A), SW56.1 (A)
unnamed: D57.2 (A), SW57.1 (A)
unnamed: D58.2 (A), SW58.1 (A)
unnamed: D59.2 (A), SW59.1 (A)
unnamed: D60.2 (A), SW60.1 (A)
unnamed: D61.2 (A), SW61.1 (A)
unnamed: D62.2 (A), SW62.1 (A)
unnamed: D63.2 (A), SW63.1 (A)
unnamed: D69.2 (A), SW64.1 (A)
unnamed: D70.2 (A), SW65.1 (A)
unnamed: D71.2 (A), SW66.1 (A)
unnamed: D72.2 (A), SW67.1 (A)
unnamed: D78.2 (A), SW68.1 (A)
unnamed: D79.2 (A), SW69.1 (A)
R1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U1.5 (SDA)
R2: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.6 (SLC)
R3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), U1.7 (D4)
R4: D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.8 (C6)
R5: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), U1.9 (D7)
R6: D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), U1.10 (E6)
R7: D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), U1.11 (B4)
R8: D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), J3.8, U1.12 (B5)
R9: D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), J1.2, J2.8

Board: 2 copper layers, 156 parts (79 on the bottom side), 97 nets, no tracks yet.
